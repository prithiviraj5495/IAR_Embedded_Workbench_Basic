# IAR project RELAY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Users\USER\Desktop\LAB24\RELAY(BUZZER)\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RELAY.hex
  ILINK.IlinkOutputFile: RELAY.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: RELAY.c stm32f4xx_rcc.c
    inc/: stm32f4xx.h stm32f4xx_rcc.h
